# Keil uVision project Project.uvprojx, settings and files
target HT32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F52241 Holtek
  pack: Holtek.HT32_DFP.1.0.28
  cpu: IROM(0x00000000-0x0000FBFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group User
    ../: main.c LED.c
  group Headers
    ../: ht32_board_config.h LED.h
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
