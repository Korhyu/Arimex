# Keil uVision project Project_52241.HT32.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32F52241_48LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.28
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0xFC00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HT32
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_HT32F52241_SK USE_HT32_DRIVER USE_MEM_HT32F52241 __EVAL __MICROLIB
  c misc: -Wno-documentation -Wno-documentation-unknown-command -Wno-license-management -Wno-missing-noreturn -Wno-missing-prototypes -Wno-missing-variable-declarations -Wno-nonportable-include-path -Wno-packed -Wno-parentheses-equality -Wno-reserved-id-macro -Wno-unused-macros -xc
  c include: ../;../Inc;../library/CMSIS/Include;../library/Device/Holtek/HT32F5xxxx/Include;../library/HT32F5xxxx_Driver/inc;../library/HT32_USBD_Library/inc;../utilities
  asm define: USE_HT32_CHIP=2 __EVAL
  library: MicroLIB
  memory RVCT4: RAM 0x0 size 0xfc00
  memory RVCT9: ROM 0x20000000 size 0x2000
  link misc: --entry 0x00000000 --entry Reset_Handler --first __Vectors --info summarysizes --load_addr_map_info --summary_stderr
  group User
    ../: main.c ht32f5xxxx_01_it.c
    ../Src/: AL00_micro_ht32f52241.c AL00_common_functions.c AL01_board_iq_aed_rev20191011.c AL02_switches_leds_mux_driver.c AL02_inverter_3phase.c AL03_motor_3phase_driver.c AL02_hairdryer_global_registers.c
    ./: AL01_flash_management.c
  group Config
    ../: ht32f5xxxx_conf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_02.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group Library
    ../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_crc.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_mctm.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../utilities/: ht32_board.c
    ../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
